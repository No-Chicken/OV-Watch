# Keil uVision project OV_Watch_V2.uvprojx, settings and files
target OV_Watch_V2 (5060960::V5.06 update 7 for Certification (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: OV_Watch_V2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: --locale=english
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Tasks\Inc;../SYSTEM;../Hardwares/AHT21;../Hardwares/BL24C02;../Hardwares/EM7028;../Hardwares/IIC;../Hardwares/LCD;../Hardwares/LSM303DLH;../Hardwares/MPU6050;../Hardwares/POWER;../Hardwares/TOUCH;../Hardwares/SPL06_001;..\Hardwares\KEY;..\Middlewares\LVGL\GUI_UserApp;..\Middlewares\LVGL\GUI\porting;..\Middlewares\LVGL\GUI\lvgl\src;..\Middlewares\LVGL\GUI;..\Middlewares\LVGL\GUI\lvgl;..\Hardwares\OWDG;..\Hardwares\HC04;..\Hardwares\ICcard
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c adc.c spi.c rtc.c gpio.c tim.c dma.c usart.c
  group Application/User/Tasks
    ../Tasks/Src/: PageStack.c StrCalculate.c user_TasksInit.c user_KeyTask.c user_StopEnterTask.c user_ScrRenewTask.c user_HomePageTask.c user_SensorPageTask.c user_ChargPageTask.c user_MessageSendTask.c user_MPUCheckTask.c
  group Application/GUI_APP
    ../Middlewares/LVGL/GUI_UserApp/: ui.c ui_helpers.c ui_Megboxes.c ui_HomePage.c ui_MenuPage.c ui_CalendarPage.c ui_ComputerPage.c ui_TimerPage.c ui_HRPage.c ui_NFCCardPage.c ui_CompassPage.c ui_AboutPage.c ui_SetPage.c ui_OffTimePage.c ui_DateTimeSetPage.c ui_SPO2Page.c ui_EnvPage.c ui_ChargPage.c
  group Application/GUI_Fonts_IMG
    ../Middlewares/LVGL/GUI_UserApp/: ui_font_Cuyuan18.c ui_font_Cuyuan20.c ui_font_Cuyuan24.c ui_font_Cuyuan30.c ui_font_Cuyuan38.c ui_font_Cuyuan48.c ui_font_Cuyuan80.c ui_font_Cuyuan100.c ui_font_iconfont16.c ui_font_iconfont24.c ui_font_iconfont28.c ui_font_iconfont30.c ui_font_iconfont32.c ui_font_iconfont34.c ui_font_iconfont45.c ui_img_compass_needle_png.c
  group Application/SYSTEM
    ../SYSTEM/: delay.c
  group Drivers/Hardwares
    ../Hardwares/AHT21/: AHT21.c
    ../Hardwares/BL24C02/: BL24C02.c
    ../Hardwares/EM7028/: em70x8.c libBpm.lib libBp.lib
    ../Hardwares/IIC/: iic_hal.c
    ../Hardwares/LCD/: lcd.c lcd_init.c
    ../Hardwares/LSM303DLH/: LSM303.c
    ../Hardwares/MPU6050/: mpu6050.c
    ../Hardwares/POWER/: power.c
    ../Hardwares/SPL06_001/: SPL06_001.c
    ../Hardwares/TOUCH/: CST816.c
    ../Hardwares/KEY/: key.c
    ../Hardwares/HC04/: HC04.c
    ../Hardwares/OWDG/: WDOG.c
    ../Hardwares/ICcard/: ICcard.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LVGL/GUI_Port
    ../Middlewares/LVGL/GUI/porting/: lv_port_disp.c lv_port_indev.c
  group Middlewares/LVGL/GUI
    ../Middlewares/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Middlewares/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/: lv_extra.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../Middlewares/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares/LVGL/GUI/lvgl/src/misc/: lv_timer.c lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../Middlewares/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
software components: CMSIS:CORE 5.6.0
